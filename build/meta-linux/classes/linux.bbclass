
# Class of Linux layer

inherit logging

IB_LINUX_PATH = "${IB_DIR}/linux/linux"


 