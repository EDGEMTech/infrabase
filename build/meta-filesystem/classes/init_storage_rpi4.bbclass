
# Specific task description for formatting
# the storage of Raspberry Pi 4 (32-bit) (rpi4) platform

inherit init_storage_arm_common
