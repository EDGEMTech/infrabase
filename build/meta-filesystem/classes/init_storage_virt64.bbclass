
# Specific task description for formatting
# the storage of virt64 platform

inherit init_storage_arm_common
