
# Specific task description for formatting
# the storage of Raspberry Pi 4 (64-bit) (rpi4_64) platform

inherit init_storage_arm_common
