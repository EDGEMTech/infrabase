
# Specific task description for formatting
# the storage of virt32 platform

inherit init_storage_arm_common
